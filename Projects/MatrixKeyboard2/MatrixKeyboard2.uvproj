# Keil uVision project MatrixKeyboard2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: object +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h port.h
    ../../Libraries/MatrixKeyboard4x4/: matrix_keyboard_4x4.c
    ../../Libraries/Delay/: delay_ms.c
