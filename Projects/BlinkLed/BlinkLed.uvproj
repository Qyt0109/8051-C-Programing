# Keil uVision project BlinkLed.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: BlinkLed +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h settings.h port.h
    Z:/Users/nmhtdytgmail.com/Embedded/8051/Libraries/Delay/: delay.c
